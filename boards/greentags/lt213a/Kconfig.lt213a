## boards/greentags/lt213a/board.yml
```yaml
board:
  name: lt213a
  full_name: Greentags LT213A
  vendor: greentags
  socs:
    - name: nrf51822
```
